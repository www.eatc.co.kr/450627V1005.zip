# Autodesk Inventor assembly: 답안조립품
## iProperties
Created: 2015-05
Part Number: 답안조립품
Document SubType Name: Assembly
Designer: Win7
Author: Win7
